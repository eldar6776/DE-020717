# Keil uVision project DE-020717.uvprojx, settings and files
target DE020717 (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.10.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: DE-020717
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F746xx,USE_STM32746G_DISCO
  c include: ..\Inc;..\Drivers\STM32F7xx_HAL_Driver\Inc;..\Drivers\BSP\STM32F746;..\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\Drivers\BSP\Components;..\Middlewares\ST\STemWin\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\DE-020717\Exe\DE-020717.sct
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/HARDWARE
    ../Drivers/BSP/Components/ft5336/: ft5336.c
    ../Drivers/BSP/Components/wm8994/: wm8994.c
    ../Drivers/BSP/STM32F746/: stm32746g.c stm32746g_audio.c stm32746g_eeprom.c stm32746g_qspi.c stm32746g_sdram.c stm32746g_ts.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dsi.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_dma2d.c stm32f7xx_ll_fmc.c stm32f7xx_hal_usart.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_sai.c stm32f7xx_hal_i2s.c
  group Middlewares/STemWin/Config
    ../Src/: GUIConf.c LCDConf.c
    ../Middlewares/ST/STemWin/OS/: GUI_X.c
  group Middlewares/STemWin/Lib
    ../Middlewares/ST/STemWin/Lib/: STemWin540_CM7_Keil.lib
  group AudioResource
    ../Src/Audio/: alarm_clock_clasic.c alarm_clock_cosmic.c alarm_clock_iphon.c alarm_clock_melodic.c alarm_clock_samsung.c door_bell_dingdong.c fire_alarm_hard.c fire_alarm_soft.c sos_alarm_entry.c
  group DisplayResource
    ../Src/Display/: Font23S_AA4.c Font23SL_AA4.c Font32S_AA4.c Font32SL_AA4.c home_icon.c weather_icon.c alarm_clock_icon.c button_round_pessed.c button_round.c bckgnd_forecast.c bckgnd_thermostat.c sun_with_cloud_image.c knob_decorate_ring.c door_bell_animation.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/User
    ../Src/: stm32f7xx_it.c waveplayer.c thermostat.c common.c one_wire.c display.c main.c
software components: CMSIS:CORE 5.1.1
