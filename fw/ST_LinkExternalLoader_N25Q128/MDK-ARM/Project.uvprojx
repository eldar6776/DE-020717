# Keil uVision project Project.uvprojx, settings and files
target N25Q128A_LDR (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746ZETx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.10.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x80000) IROM2(0x00200000,0x80000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: N25Q128A_LDR +hex
  AfterMake: cmd.exe /C copy "!L" "..\..\@L.stldr"
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c include: ..\Inc;C:\Users\Drivers\BSP\Components\Common;C:\Users\Utilities\Log;C:\Users\Utilities\CPU;C:\Users\Drivers\CMSIS\Include;C:\Users\Drivers\CMSIS\Device\ST\STM32F7xx\Include;C:\Users\Drivers\STM32F7xx_HAL_Driver\Inc;C:\Users\Drivers\BSP\STM32F769I_EVAL;C:\Users\Drivers\BSP\Components\n25q128a
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\Target.sct
  link misc: --diag_suppress=L6244
  group Example/User
    ../Src/: Dev_Inf.c Loader_Src.c stm32f7xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    C:/Users/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_dma.c
  group Drivers/CMSIS
    C:/Users/Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
