# Keil uVision project DE-170518.uvprojx, settings and files
target DE-170518 (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F746ZETx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.10.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x80000) IROM2(0x00200000,0x80000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: DE-170518 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F746xx
  c include: ..\Inc;..\Drivers\STM32F7xx_HAL_Driver\Inc;..\Drivers\BSP\STM32F746;..\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\Drivers\BSP\Components;..\Middlewares\ST\STemWin\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\DE-170518\Exe\DE-170518.sct
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/HARDWARE
    ../Drivers/BSP/Components/ft5336/: ft5336.c
    ../Drivers/BSP/Components/wm8994/: wm8994.c
    ../Drivers/BSP/STM32F746/: stm32746g.c stm32746g_ts.c stm32746g_qspi.c stm32746g_sdram.c stm32746g_eeprom.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dsi.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_dma2d.c stm32f7xx_ll_fmc.c stm32f7xx_hal_usart.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_sai.c stm32f7xx_hal_i2s.c stm32f7xx_hal_iwdg.c
  group Middlewares/STemWin/Config
    ../Src/: GUIConf.c LCDConf.c
    ../Middlewares/ST/STemWin/OS/: GUI_X.c
  group Middlewares/STemWin/Lib
    ../Middlewares/ST/STemWin/Lib/: STemWin540_CM7_Keil.lib
  group DisplayResource
    ../Src/Display/: number_0.c number_1.c number_2.c number_3.c number_4.c number_5.c number_6.c number_7.c number_8.c number_9.c btn_decrease.c btn_dnd_0.c btn_dnd_1.c btn_increase.c btn_maid_0.c btn_maid_1.c btn_ok.c btn_open_door.c btn_rst_sos_0.c btn_rst_sos_1.c display_0.c display_1.c display_2.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/User
    ../Src/: stm32f7xx_it.c thermostat.c common.c one_wire.c display.c main.c
software components: CMSIS:CORE 5.1.1
